# Keil uVision project Plantilla_mk20.uvprojx, settings and files
target MK20D50M (6220000::V6.22::ARMCLANG)
  device: MK20DX128xxx5 NXP
  pack: Keil.Kinetis_K20_DFP.1.7.1
  cpu: IRAM(0x20000000,0x00002000) IRAM2(0x1FFFE000,0x00002000) IROM(0x00000000,0x00020000) IROM2(0x10000000,0x00008000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Plantilla_mk20
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  group User_Aplication
    ./: main.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
